# Keil uVision project DishwasherWaterControl.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DishwasherWaterControl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\common;..\include
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
  group common
    ../common/: main.h config.h
  group include
    ./: led.h
    ../include/: key.h
  group source
    ../source/: main.c key.c
    ./: led.c

# Keil uVision project Dishwasher.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Dishwasher +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\common;..\include
  group Source Group 1
    ./: STARTUP.A51
  group common
    ../common/: config.h head.h
  group source
    ../source/: beep.c infrared.c key.c lcd1602.c led.c relay.c timer.c uart.c xpt2046.c
  group include
    ../include/: beep.h infrared.h key.h lcd1602.h led.h relay.h timer.h uart.h xpt2046.h
  group app
    ../app/: main.c
